# Autodesk Inventor assembly: ex7-6a
## iProperties
Created: 2007-03
Part Number: ex7-6a
Document SubType Name: Assembly
Designer: NEV96356
Author: NEV96356
