# Autodesk Inventor assembly: ex7-7
## iProperties
Created: 2007-03
Part Number: ex7-7
Document SubType Name: Assembly
Designer: NEV96356
Author: NEV96356
