# Autodesk Inventor assembly: ex7-9
## iProperties
Created: 2007-03
Part Number: ex7-9
Document SubType Name: Assembly
Designer: NEV96356
Author: NEV96356
